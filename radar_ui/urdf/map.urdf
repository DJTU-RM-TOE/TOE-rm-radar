Commit message: rebuild

File: radar_ui/urdf/map.urdf (robot description, URDF)
Before this commit: robot my_robot, 1 links, 0 joints
Links:
- link map: geometry visual mesh filename=file:///home/evence/ros2_ws/toe_ctrl/src/TOE-rm-radar/radar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 scale=0.1 0.1 0.1
